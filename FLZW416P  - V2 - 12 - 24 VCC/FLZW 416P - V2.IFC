Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: I:\A - PROJETO NOVO WORKSPACE\ENGENHARIA LUMINARIA\A - PROJETOS & DESENVOLVIMENTO\FLZW 41 - V2\EM ANDAMENTO\DESENHOS\MONTAGEM\FLZW 416P - POSTE 30°\PARA ENVIO\FLZW 416P - V2.IFC
Time: 2024-11-06T16:41:04+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
